## drivers/usb/gadget/raw/Kconfig
```kconfig
config USB_RAW_GADGET
	tristate "USB Raw Gadget"
	depends on DEBUG_FS
	help
	  TODO: USB Raw Gadget
```
